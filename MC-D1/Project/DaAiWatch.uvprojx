# Keil uVision project DaAiWatch.uvprojx, settings and files
target nrf52832 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD __STACK_SIZE=2048 __HEAP_SIZE=1024 S132 NRF_SD_BLE_API_VERSION=5 NRF52_PAN_58 NRF52_PAN_64 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 CONFIG_GPIO_AS_PINRESET NRF52_PAN_55 SOFTDEVICE_PRESENT NRF52832 NRF52 FREERTOS
  c include: ..\User;..\User\hex;..\User\config;..\nrf52832\ble\ble_advertising;..\nrf52832\ble\ble_dtm;..\nrf52832\ble\ble_racp;..\nrf52832\ble\ble_services\ble_ancs_c;..\nrf52832\ble\ble_services\ble_ans_c;..\nrf52832\ble\ble_services\ble_bas;..\nrf52832\ble\ble_services\ble_bas_c;..\nrf52832\ble\ble_services\ble_cscs;..\nrf52832\ble\ble_services\ble_cts_c;..\nrf52832\ble\ble_services\ble_dfu;..\nrf52832\ble\ble_services\ble_dis;..\nrf52832\ble\ble_services\ble_gls;..\nrf52832\ble\ble_services\ble_hids;..\nrf52832\ble\ble_services\ble_hrs;..\nrf52832\ble\ble_services\ble_hrs_c;..\nrf52832\ble\ble_services\ble_hts;..\nrf52832\ble\ble_services\ble_ias;..\nrf52832\ble\ble_services\ble_ias_c;..\nrf52832\ble\ble_services\ble_lbs;..\nrf52832\ble\ble_services\ble_lbs_c;..\nrf52832\ble\ble_services\ble_lls;..\nrf52832\ble\ble_services\ble_nus;..\nrf52832\ble\ble_services\ble_nus_c;..\nrf52832\ble\ble_services\ble_rscs;..\nrf52832\ble\ble_services\ble_rscs_c;..\nrf52832\ble\ble_services\ble_tps;..\nrf52832\ble\common;..\nrf52832\ble\nrf_ble_gatt;..\nrf52832\ble\nrf_ble_qwr;..\nrf52832\ble\peer_manager;..\nrf52832\boards;..\nrf52832\drivers_nrf\clock;..\nrf52832\drivers_nrf\common;..\nrf52832\drivers_nrf\comp;..\nrf52832\drivers_nrf\delay;..\nrf52832\drivers_nrf\gpiote;..\nrf52832\drivers_nrf\hal;..\nrf52832\drivers_nrf\i2s;..\nrf52832\drivers_nrf\lpcomp;..\nrf52832\drivers_nrf\pdm;..\nrf52832\drivers_nrf\power;..\nrf52832\drivers_nrf\ppi;..\nrf52832\drivers_nrf\pwm;..\nrf52832\drivers_nrf\qdec;..\nrf52832\drivers_nrf\rng;..\nrf52832\drivers_nrf\rtc;..\nrf52832\drivers_nrf\saadc;..\nrf52832\drivers_nrf\spi_master;..\nrf52832\drivers_nrf\spi_slave;..\nrf52832\drivers_nrf\swi;..\nrf52832\drivers_nrf\timer;..\nrf52832\drivers_nrf\twi_master;..\nrf52832\drivers_nrf\twis_slave;..\nrf52832\drivers_nrf\uart;..\nrf52832\drivers_nrf\usbd;..\nrf52832\drivers_nrf\wdt;..\nrf52832\libraries\bsp;..\nrf52832\libraries\button;..\nrf52832\libraries\crc16;..\nrf52832\libraries\crc32;..\nrf52832\libraries\csense;..\nrf52832\libraries\csense_drv;..\nrf52832\libraries\ecc;..\nrf52832\libraries\experimental_section_vars;..\nrf52832\libraries\fds;..\nrf52832\libraries\fstorage;..\nrf52832\libraries\fifo;..\nrf52832\libraries\gpiote;..\nrf52832\libraries\hardfault;..\nrf52832\libraries\hardfault\nrf52;..\nrf52832\libraries\hci;..\nrf52832\libraries\led_softblink;..\nrf52832\libraries\log;..\nrf52832\libraries\log\src;..\nrf52832\libraries\low_power_pwm;..\nrf52832\libraries\mem_manager;..\nrf52832\libraries\pwm;..\nrf52832\libraries\queue;..\nrf52832\libraries\scheduler;..\nrf52832\libraries\sensorsim;..\nrf52832\libraries\slip;..\nrf52832\libraries\timer;..\nrf52832\libraries\twi;..\nrf52832\libraries\uart;..\nrf52832\libraries\usbd;..\nrf52832\libraries\usbd\class\audio;..\nrf52832\libraries\usbd\class\cdc;..\nrf52832\libraries\usbd\class\cdc\acm;..\nrf52832\libraries\usbd\class\hid;..\nrf52832\libraries\usbd\class\hid\generic;..\nrf52832\libraries\usbd\class\hid\kbd;..\nrf52832\libraries\usbd\class\hid\mouse;..\nrf52832\libraries\usbd\class\msc;..\nrf52832\libraries\usbd\config;..\nrf52832\libraries\util;..\nrf52832\softdevice\common\softdevice_handler;..\nrf52832\softdevice\s132\headers;..\nrf52832\softdevice\s132\headers\nrf52;..\nrf52832\toolchain;..\external\freertos\config;..\external\freertos\portable\ARM\nrf52;..\external\freertos\portable\CMSIS\nrf52;..\external\freertos\source\include;..\external\segger_rtt
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__STACK_SIZE=2048,-D__HEAP_SIZE=1024,-DS132,-DNRF_SD_BLE_API_VERSION=5,-DNRF52_PAN_58,-DNRF52_PAN_64,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_55,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DFREERTOS
  asm include: ..\User;..\User\config;..\nrf52832\ble\ble_advertising;..\nrf52832\ble\ble_dtm;..\nrf52832\ble\ble_racp;..\nrf52832\ble\ble_services\ble_ancs_c;..\nrf52832\ble\ble_services\ble_ans_c;..\nrf52832\ble\ble_services\ble_bas;..\nrf52832\ble\ble_services\ble_bas_c;..\nrf52832\ble\ble_services\ble_cscs;..\nrf52832\ble\ble_services\ble_cts_c;..\nrf52832\ble\ble_services\ble_dfu;..\nrf52832\ble\ble_services\ble_dis;..\nrf52832\ble\ble_services\ble_gls;..\nrf52832\ble\ble_services\ble_hids;..\nrf52832\ble\ble_services\ble_hrs;..\nrf52832\ble\ble_services\ble_hrs_c;..\nrf52832\ble\ble_services\ble_hts;..\nrf52832\ble\ble_services\ble_ias;..\nrf52832\ble\ble_services\ble_ias_c;..\nrf52832\ble\ble_services\ble_lbs;..\nrf52832\ble\ble_services\ble_lbs_c;..\nrf52832\ble\ble_services\ble_lls;..\nrf52832\ble\ble_services\ble_nus;..\nrf52832\ble\ble_services\ble_nus_c;..\nrf52832\ble\ble_services\ble_rscs;..\nrf52832\ble\ble_services\ble_rscs_c;..\nrf52832\ble\ble_services\ble_tps;..\nrf52832\ble\common;..\nrf52832\ble\nrf_ble_gatt;..\nrf52832\ble\nrf_ble_qwr;..\nrf52832\ble\peer_manager;..\nrf52832\boards;..\nrf52832\drivers_nrf\clock;..\nrf52832\drivers_nrf\common;..\nrf52832\drivers_nrf\comp;..\nrf52832\drivers_nrf\delay;..\nrf52832\drivers_nrf\gpiote;..\nrf52832\drivers_nrf\hal;..\nrf52832\drivers_nrf\i2s;..\nrf52832\drivers_nrf\lpcomp;..\nrf52832\drivers_nrf\pdm;..\nrf52832\drivers_nrf\power;..\nrf52832\drivers_nrf\ppi;..\nrf52832\drivers_nrf\pwm;..\nrf52832\drivers_nrf\qdec;..\nrf52832\drivers_nrf\rng;..\nrf52832\drivers_nrf\rtc;..\nrf52832\drivers_nrf\saadc;..\nrf52832\drivers_nrf\spi_master;..\nrf52832\drivers_nrf\spi_slave;..\nrf52832\drivers_nrf\swi;..\nrf52832\drivers_nrf\timer;..\nrf52832\drivers_nrf\twi_master;..\nrf52832\drivers_nrf\twis_slave;..\nrf52832\drivers_nrf\uart;..\nrf52832\drivers_nrf\usbd;..\nrf52832\drivers_nrf\wdt;..\nrf52832\libraries\bsp;..\nrf52832\libraries\button;..\nrf52832\libraries\crc16;..\nrf52832\libraries\crc32;..\nrf52832\libraries\csense;..\nrf52832\libraries\csense_drv;..\nrf52832\libraries\ecc;..\nrf52832\libraries\experimental_section_vars;..\nrf52832\libraries\fds;..\nrf52832\libraries\fstorage;..\nrf52832\libraries\gpiote;..\nrf52832\libraries\hardfault;..\nrf52832\libraries\hardfault\nrf52;..\nrf52832\libraries\hci;..\nrf52832\libraries\led_softblink;..\nrf52832\libraries\log;..\nrf52832\libraries\log\src;..\nrf52832\libraries\low_power_pwm;..\nrf52832\libraries\mem_manager;..\nrf52832\libraries\pwm;..\nrf52832\libraries\queue;..\nrf52832\libraries\scheduler;..\nrf52832\libraries\sensorsim;..\nrf52832\libraries\slip;..\nrf52832\libraries\timer;..\nrf52832\libraries\twi;..\nrf52832\libraries\uart;..\nrf52832\libraries\usbd;..\nrf52832\libraries\usbd\class\audio;..\nrf52832\libraries\usbd\class\cdc;..\nrf52832\libraries\usbd\class\cdc\acm;..\nrf52832\libraries\usbd\class\hid;..\nrf52832\libraries\usbd\class\hid\generic;..\nrf52832\libraries\usbd\class\hid\kbd;..\nrf52832\libraries\usbd\class\hid\mouse;..\nrf52832\libraries\usbd\class\msc;..\nrf52832\libraries\usbd\config;..\nrf52832\libraries\util;..\nrf52832\softdevice\common\softdevice_handler;..\nrf52832\softdevice\s132\headers;..\nrf52832\softdevice\s132\headers\nrf52;..\nrf52832\toolchain;..\external\freertos\config;..\external\freertos\portable\ARM\nrf52;..\external\freertos\portable\CMSIS\nrf52;..\external\freertos\source\include;..\external\segger_rtt;config
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x60000
  memory RVCT9: RAM 0x20002168 size 0xde98
  group Application
    ../User/: main.c data_storage.c
    ../User/config/: sdk_config.h
  group Board Definition
    ../nrf52832/boards/: boards.c
  group Board Support
    ../nrf52832/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group Documentation
    ../User/config/: license.txt
  group Third Parties
    ../external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../external/freertos/source/portable/MemMang/: heap_1.c
    ../external/freertos/portable/ARM/nrf52/: port.c
    ../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group nRF_BLE
    ../nrf52832/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../nrf52832/ble/ble_advertising/: ble_advertising.c
    ../nrf52832/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../nrf52832/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../nrf52832/ble/ble_services/ble_bas/: ble_bas.c
    ../nrf52832/ble/ble_services/ble_dis/: ble_dis.c
    ../nrf52832/ble/ble_services/ble_hrs/: ble_hrs.c
    ../nrf52832/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../nrf52832/drivers_nrf/clock/: nrf_drv_clock.c
    ../nrf52832/drivers_nrf/common/: nrf_drv_common.c
    ../nrf52832/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../nrf52832/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../nrf52832/libraries/button/: app_button.c
    ../nrf52832/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../nrf52832/libraries/timer/: app_timer_freertos.c
    ../nrf52832/libraries/crc16/: crc16.c
    ../nrf52832/libraries/fds/: fds.c
    ../nrf52832/libraries/fstorage/: fstorage.c
    ../nrf52832/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../nrf52832/libraries/hardfault/: hardfault_implementation.c
    ../nrf52832/libraries/sensorsim/: sensorsim.c
    ../nrf52832/libraries/uart/: app_uart_fifo.c
    ../nrf52832/libraries/fifo/: app_fifo.c
  group nRF_Log
    ../nrf52832/libraries/log/src/: nrf_log_frontend.c nrf_log_backend_serial.c
  group nRF_Segger_RTT
    ../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../nrf52832/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s132_nrf52_5.0.0-1.alpha_softdevice (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: as above
  output: DaAiWatch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD __STACK_SIZE=2048 __HEAP_SIZE=1024 S132 NRF_SD_BLE_API_VERSION=5 NRF52_PAN_58 NRF52_PAN_64 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 CONFIG_GPIO_AS_PINRESET NRF52_PAN_55 SOFTDEVICE_PRESENT NRF52832 NRF52 FREERTOS USE_STDPERIPH_DRIVER
  c include: ..\User;..\User\config;..\nrf52832;..\nrf52832\ble\ble_advertising;..\nrf52832\ble\ble_dtm;..\nrf52832\ble\ble_racp;..\nrf52832\ble\ble_services\ble_ancs_c;..\nrf52832\ble\ble_services\ble_ans_c;..\nrf52832\ble\ble_services\ble_bas;..\nrf52832\ble\ble_services\ble_bas_c;..\nrf52832\ble\ble_services\ble_cscs;..\nrf52832\ble\ble_services\ble_cts_c;..\nrf52832\ble\ble_services\ble_dfu;..\nrf52832\ble\ble_services\ble_dis;..\nrf52832\ble\ble_services\ble_gls;..\nrf52832\ble\ble_services\ble_hids;..\nrf52832\ble\ble_services\ble_hrs;..\nrf52832\ble\ble_services\ble_hrs_c;..\nrf52832\ble\ble_services\ble_hts;..\nrf52832\ble\ble_services\ble_ias;..\nrf52832\ble\ble_services\ble_ias_c;..\nrf52832\ble\ble_services\ble_lbs;..\nrf52832\ble\ble_services\ble_lbs_c;..\nrf52832\ble\ble_services\ble_lls;..\nrf52832\ble\ble_services\ble_nus;..\nrf52832\ble\ble_services\ble_nus_c;..\nrf52832\ble\ble_services\ble_rscs;..\nrf52832\ble\ble_services\ble_rscs_c;..\nrf52832\ble\ble_services\ble_tps;..\nrf52832\ble\common;..\nrf52832\ble\nrf_ble_gatt;..\nrf52832\ble\nrf_ble_qwr;..\nrf52832\ble\peer_manager;..\nrf52832\boards;..\nrf52832\drivers_nrf\clock;..\nrf52832\drivers_nrf\common;..\nrf52832\drivers_nrf\comp;..\nrf52832\drivers_nrf\delay;..\nrf52832\drivers_nrf\gpiote;..\nrf52832\drivers_nrf\hal;..\nrf52832\drivers_nrf\i2s;..\nrf52832\drivers_nrf\lpcomp;..\nrf52832\drivers_nrf\pdm;..\nrf52832\drivers_nrf\power;..\nrf52832\drivers_nrf\ppi;..\nrf52832\drivers_nrf\pwm;..\nrf52832\drivers_nrf\qdec;..\nrf52832\drivers_nrf\rng;..\nrf52832\drivers_nrf\rtc;..\nrf52832\drivers_nrf\saadc;..\nrf52832\drivers_nrf\spi_master;..\nrf52832\drivers_nrf\spi_slave;..\nrf52832\drivers_nrf\swi;..\nrf52832\drivers_nrf\timer;..\nrf52832\drivers_nrf\twi_master;..\nrf52832\drivers_nrf\twis_slave;..\nrf52832\drivers_nrf\uart;..\nrf52832\drivers_nrf\usbd;..\nrf52832\drivers_nrf\wdt;..\nrf52832\libraries\bsp;..\nrf52832\libraries\button;..\nrf52832\libraries\crc16;..\nrf52832\libraries\crc32;..\nrf52832\libraries\csense;..\nrf52832\libraries\csense_drv;..\nrf52832\libraries\ecc;..\nrf52832\libraries\experimental_section_vars;..\nrf52832\libraries\fds;..\nrf52832\libraries\fstorage;..\nrf52832\libraries\gpiote;..\nrf52832\libraries\hardfault;..\nrf52832\libraries\hardfault\nrf52;..\nrf52832\libraries\hci;..\nrf52832\libraries\led_softblink;..\nrf52832\libraries\log;..\nrf52832\libraries\log\src;..\nrf52832\libraries\low_power_pwm;..\nrf52832\libraries\mem_manager;..\nrf52832\libraries\pwm;..\nrf52832\libraries\queue;..\nrf52832\libraries\scheduler;..\nrf52832\libraries\sensorsim;..\nrf52832\libraries\slip;..\nrf52832\libraries\timer;..\nrf52832\libraries\twi;..\nrf52832\libraries\uart;..\nrf52832\libraries\usbd;..\nrf52832\libraries\usbd\class\audio;..\nrf52832\libraries\usbd\class\cdc;..\nrf52832\libraries\usbd\class\cdc\acm;..\nrf52832\libraries\usbd\class\hid;..\nrf52832\libraries\usbd\class\hid\generic;..\nrf52832\libraries\usbd\class\hid\kbd;..\nrf52832\libraries\usbd\class\hid\mouse;..\nrf52832\libraries\usbd\class\msc;..\nrf52832\libraries\usbd\config;..\nrf52832\libraries\util;..\nrf52832\softdevice\common\softdevice_handler;..\nrf52832\softdevice\s132\headers;..\nrf52832\softdevice\s132\headers\nrf52;..\nrf52832\toolchain;..\external\freertos\config;..\external\freertos\portable\ARM\nrf52;..\external\freertos\portable\CMSIS\nrf52;..\external\freertos\source\include;..\external\segger_rtt;.\config
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x60000
  memory RVCT9: RAM 0x20002168 size 0xde98
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
